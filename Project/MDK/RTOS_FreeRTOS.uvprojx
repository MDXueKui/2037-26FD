# Keil uVision project RTOS_FreeRTOS.uvprojx, settings and files
target APM32F030_FreeRTOS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: APM32F030C8 Geehy
  pack: Geehy.APM32F0xx_DFP.1.0.9
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: APM32F030_FreeRTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: APM32F030x8,BOARD_APM32F030_MINI
  c include: ..\..\..\..\..\Boards;..\..\Include;..\..\FreeRTOS\FreeRTOSv202012.00\FreeRTOS\Source;..\..\FreeRTOS\FreeRTOSv202012.00\FreeRTOS\Source\include;..\..\FreeRTOS\FreeRTOSv202012.00\FreeRTOS\Source\portable\RVDS\ARM_CM0;..\..\FreeRTOS\FreeRTOSv202012.00\FreeRTOS\Source\portable\MemMang;..\..\Libraries\APM32F0xx_StdPeriphDriver\inc;..\..\Libraries\CMSIS\Include;..\..\Libraries\Device\Geehy\APM32F0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../../Source/: system_apm32f0xx.c
    ../../Libraries/Device/Geehy/APM32F0xx/Source/arm/: startup_apm32f030.s
  group StdPeriphDriver
    ../../Libraries/APM32F0xx_StdPeriphDriver/src/: apm32f0xx_adc.c apm32f0xx_can.c apm32f0xx_cec.c apm32f0xx_comp.c apm32f0xx_crc.c apm32f0xx_crs.c apm32f0xx_dac.c apm32f0xx_dbg.c apm32f0xx_dma.c apm32f0xx_eint.c apm32f0xx_fmc.c apm32f0xx_gpio.c apm32f0xx_i2c.c apm32f0xx_iwdt.c apm32f0xx_misc.c apm32f0xx_ob.c apm32f0xx_pmu.c apm32f0xx_rcm.c apm32f0xx_rtc.c apm32f0xx_spi.c apm32f0xx_syscfg.c apm32f0xx_tmr.c apm32f0xx_usart.c apm32f0xx_wwdt.c
  group Application
    ../../Source/: main.c apm32f0xx_int.c uart_debug.c malloc.c input_scan.c tm1650.c
  group FREE_RTOS
    ../../FreeRTOS/FreeRTOSv202012.00/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../FreeRTOS/FreeRTOSv202012.00/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    ../../FreeRTOS/FreeRTOSv202012.00/FreeRTOS/Source/portable/MemMang/: heap_4.c
target APM32F072_FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: APM32F072VB Geehy
  pack: Geehy.APM32F0xx_DFP.1.0.9
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: APM32F072_FreeRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: APM32F072xB,BOARD_APM32F072_MINI
  c include: ..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\Boards;..\..\Include;..\..\..\..\..\Middlewares\FreeRTOS\FreeRTOSv202012.00\FreeRTOS\Source;..\..\..\..\..\Middlewares\FreeRTOS\FreeRTOSv202012.00\FreeRTOS\Source\include;..\..\..\..\..\Middlewares\FreeRTOS\FreeRTOSv202012.00\FreeRTOS\Source\portable\RVDS\ARM_CM0;..\..\..\..\..\Middlewares\FreeRTOS\FreeRTOSv202012.00\FreeRTOS\Source\portable\MemMang;..\..\..\..\..\Libraries\APM32F0xx_StdPeriphDriver\inc;..\..\..\..\..\Libraries\Device\Geehy\APM32F0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
